# Keil uVision project MDK-ARM-STM32F2xx.uvproj, settings and files
target MDK-RTX-TCP-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F2xx-MDK-RTX-TCP-FS
  c flags: Optim=1
  c define: HAVE_CONFIG_H CYASSL_STM32F2xx __DBG_ITM __RTX USE_STDPERIPH_DRIVER MDK_CONF_RTX_TCP_FS
  c include: ..\MDK-ARM\CyaSSL;C:..\STM32F2xx_StdPeriph_Lib\inc;..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CyaSSL Apps
    ../../../examples/echoclient/: echoclient.c
    ../../../examples/echoserver/: echoserver.c
    ../../../ctaocrypt/test/: test.c
    ../../../ctaocrypt/benchmark/: benchmark.c
    ../../../examples/client/: client.c
    ../../../examples/server/: server.c
    ../MDK-ARM/CyaSSL/: shell.c main.c cert_data.c
  group STM32F2xx_StdPeriph_Lib
    ../STM32F2xx_StdPeriph_Lib/src/: stm32f2xx_cryp.c stm32f2xx_hash.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_pwr.c stm32f2xx_tim.c
  group MDK-ARM
    c:/Keil/ARM/Boards/Keil/MCBSTM32F200/RL/FlashFS/SD_File/: Serial.c
    c:/Keil/ARM/RL/FlashFS/Drivers/: SDIO_STM32F2xx.c
    c:/Keil/ARM/RV31/LIB/: FS_CM3.lib TCPD_CM3.lib TCP_CM3.lib
    c:/Keil/ARM/RV31/LIB//: RTX_CM3.lib
    c:/Keil/ARM/RL/TCPnet/Drivers/: ETH_STM32F2xx.c
    C:/Keil/ARM/Startup/ST/STM32F2xx/: system_stm32f2xx.c
  group CyaSSL Library
    ../../../src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
    ../MDK-ARM/CyaSSL/: ssl-dummy.c
  group Crypt/Cipher Library
    ../../../ctaocrypt/src/: aes.c arc4.c asm.c asn.c camellia.c coding.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c
  group Configuration
    ../MDK-ARM/config/: File_Config.c Net_Config.c RTX_Conf_CM.c Net_Debug.c startup_stm32f2xx.s
    ../MDK-ARM/CyaSSL/: config.h config-FS.h config-RTX-TCP-FS.h config-BARE-METAL.h
  group CyaSSL-MDK
    ../MDK-ARM/CyaSSL/: cyassl_MDK_ARM.c Retarget.c
    ../STM32F2xx_StdPeriph_Lib/: time-STM32F2xx.c
target MDK-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: STM32F2xx-MDK-FS
  c flags: Optim=1
  c define: HAVE_CONFIG_H  CYASSL_STM32F2xx __DBG_ITM USE_STDPERIPH_DRIVER  MDK_CONF_FS
  c include: ..\MDK-ARM\CyaSSL;..\MDK-ARM\inc;..\STM32F2xx_StdPeriph_Lib\inc;..\POSIX\..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target MDK-BARE-METAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: STM32F2xx-MDK-BARE-METAL
  c flags: Optim=1
  c define: HAVE_CONFIG_H  CYASSL_STM32F2xx  __DBG_ITM USE_STDPERIPH_DRIVER MDK_CONF_BARE_METAL
  c include: ..\MDK-ARM\CyaSSL;..\MDK-ARM\inc;..\STM32F2xx_StdPeriph_Lib\inc;..\POSIX;..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
